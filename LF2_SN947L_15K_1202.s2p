!  201
# MHZ S MA R 50
! Worked out from all points (reflecting one-port):
!   201 points, 300 kHz to 3 GHz, reference 50 ohm
!   lowest |S11| = 20.0 dB at 119.7 MHz (marker M1)
!   phase of S11 starts at 18 deg and turns -2225 deg over the sweep
!   the Smith chart shows 104.8 MHz to 149.5 MHz only
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! magnitudes (dB):
! f  S11
! 300 kHz  20.1
! 119.7 MHz  20.0
! 507.7 MHz  21.7
! 895.7 MHz  25.0
! 1 GHz  23.7
! 1.075 GHz  23.9
! 1.09 GHz  25.8
! 1.179 GHz  23.3
! 1.508 GHz  26.1
! 1.523 GHz  25.0
! 1.537 GHz  27.4
! 1.552 GHz  24.3
! 1.567 GHz  26.1
! 1.597 GHz  23.5
! 1.612 GHz  25.9
! 2 GHz  24.3
! 2.209 GHz  22.6
! 2.284 GHz  24.7
! 2.388 GHz  22.5
! 2.418 GHz  24.5
! 2.508 GHz  22.8
! 3 GHz  21.9
